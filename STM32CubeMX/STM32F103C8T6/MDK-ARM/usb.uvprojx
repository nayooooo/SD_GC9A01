# Keil uVision project usb.uvprojx, settings and files
target usb (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: usb +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/At/include;../Middlewares/Third_Party/mem;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/SD
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: at_user.c lcd_init.c lcd.c main.c gpio.c spi.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/At
    ../Middlewares/Third_Party/At/: at.c at_mem.c at_stream_device.c
  group Middlewares/mem
    ../Middlewares/Third_Party/mem/: malloc.c
  group Application/User/FATFS/Target
    ../FATFS/Target/: user_diskio.c
  group Application/User/FATFS/App
    ../FATFS/App/: fatfs.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
  group Middlewares/SD
    ../Middlewares/Third_Party/SD/: MMC_SD.C
  group Middlewares/FFT
    ../Middlewares/Third_Party/FFT/: complex.c fft.c
  group Middlewares/LVGL
    ../Middlewares/lvgl/src/: lv_init.c
  group Middlewares/LVGL/Port
    ../Middlewares/lvgl/: lv_port_disp.c
  group Middlewares/LVGL/App
    ../Middlewares/lvgl/app/: lvgl_app.c
  group Middlewares/LVGL/Core
    ../Middlewares/lvgl/src/core/: lv_group.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_event.c lv_obj_id_builtin.c lv_obj_pos.c lv_obj_property.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c
  group Middlewares/LVGL/Display
    ../Middlewares/lvgl/src/display/: lv_display.c
  group Middlewares/LVGL/Draw
    ../Middlewares/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_buf.c lv_draw_image.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_draw_vector.c lv_image_buf.c lv_image_decoder.c
    ../Middlewares/lvgl/src/draw/sdl/: lv_draw_sdl.c
    ../Middlewares/lvgl/src/draw/nxp/pxp/: lv_draw_buf_pxp.c lv_draw_pxp.c lv_draw_pxp_bg_img.c lv_draw_pxp_fill.c lv_draw_pxp_img.c lv_draw_pxp_layer.c lv_pxp_cfg.c lv_pxp_osa.c lv_pxp_utils.c
    ../Middlewares/lvgl/src/draw/nxp/vglite/: lv_draw_buf_vglite.c lv_draw_vglite.c lv_draw_vglite_arc.c lv_draw_vglite_bg_img.c lv_draw_vglite_border.c lv_draw_vglite_fill.c lv_draw_vglite_img.c lv_draw_vglite_label.c lv_draw_vglite_layer.c lv_draw_vglite_line.c lv_vglite_buf.c lv_vglite_matrix.c lv_vglite_path.c lv_vglite_utils.c
    ../Middlewares/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_bg_img.c lv_draw_sw_border.c lv_draw_sw_box_shadow.c lv_draw_sw_fill.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_mask.c lv_draw_sw_mask_rect.c lv_draw_sw_transform.c lv_draw_sw_triangle.c lv_draw_sw_vector.c
    ../Middlewares/lvgl/src/draw/sw/blend/: lv_draw_sw_blend.c lv_draw_sw_blend_to_rgb565.c lv_draw_sw_blend_to_argb8888.c lv_draw_sw_blend_to_rgb888.c
  group Middlewares/LVGL/Font
    ../Middlewares/lvgl/src/font/: lv_binfont_loader.c lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_montserrat_14.c
  group Middlewares/LVGL/Indev
    ../Middlewares/lvgl/src/indev/: lv_indev.c lv_indev_scroll.c
  group Middlewares/LVGL/Layouts
    ../Middlewares/lvgl/src/layouts/: lv_layout.c
    ../Middlewares/lvgl/src/layouts/flex/: lv_flex.c
    ../Middlewares/lvgl/src/layouts/grid/: lv_grid.c
  group Middlewares/LVGL/Libs
    ../Middlewares/lvgl/src/libs/barcode/: code128.c lv_barcode.c
    ../Middlewares/lvgl/src/libs/bin_decoder/: lv_bin_decoder.c
    ../Middlewares/lvgl/src/libs/bmp/: lv_bmp.c
    ../Middlewares/lvgl/src/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/lvgl/src/libs/freetype/: lv_freetype.c lv_freetype_image.c lv_freetype_outline.c lv_freetype_sbit.c lv_ftsystem.c
    ../Middlewares/lvgl/src/libs/fsdrv/: lv_fs_cbfs.c lv_fs_fatfs.c lv_fs_memfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares/lvgl/src/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/lvgl/src/libs/libjpeg_turbo/: lv_libjpeg_turbo.c
    ../Middlewares/lvgl/src/libs/libpng/: lv_libpng.c
    ../Middlewares/lvgl/src/libs/lodepng/: lodepng.c lv_lodepng.c
    ../Middlewares/lvgl/src/libs/lz4/: lz4.c
    ../Middlewares/lvgl/src/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/lvgl/src/libs/rle/: lv_rle.c
    ../Middlewares/lvgl/src/libs/rlottie/: lv_rlottie.c
    ../Middlewares/lvgl/src/libs/tiny_ttf/: lv_tiny_ttf.c
    ../Middlewares/lvgl/src/libs/tjpgd/: lv_tjpgd.c tjpgd.c
  group Middlewares/LVGL/Misc
    ../Middlewares/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_array.c lv_async.c lv_bidi.c lv_cache.c lv_cache_builtin.c lv_color.c lv_color_op.c lv_event.c lv_fs.c lv_ll.c lv_log.c lv_lru.c lv_lru_rb.c lv_math.c lv_palette.c lv_profiler_builtin.c lv_rb.c lv_style.c lv_style_gen.c lv_templ.c lv_text.c lv_text_ap.c lv_timer.c lv_utils.c
  group Middlewares/LVGL/Osal
    ../Middlewares/lvgl/src/osal/: lv_cmsis_rtos2.c lv_freertos.c lv_os_none.c lv_pthread.c lv_rtthread.c lv_windows.c
  group Middlewares/LVGL/Others
    ../Middlewares/lvgl/src/others/file_explorer/: lv_file_explorer.c
    ../Middlewares/lvgl/src/others/fragment/: lv_fragment.c lv_fragment_manager.c
    ../Middlewares/lvgl/src/others/gridnav/: lv_gridnav.c
    ../Middlewares/lvgl/src/others/ime/: lv_ime_pinyin.c
    ../Middlewares/lvgl/src/others/imgfont/: lv_imgfont.c
    ../Middlewares/lvgl/src/others/monkey/: lv_monkey.c
    ../Middlewares/lvgl/src/others/observer/: lv_observer.c
    ../Middlewares/lvgl/src/others/snapshot/: lv_snapshot.c
    ../Middlewares/lvgl/src/others/sysmon/: lv_sysmon.c
  group Middlewares/LVGL/Stdlib
    ../Middlewares/lvgl/src/stdlib/: lv_mem.c
    ../Middlewares/lvgl/src/stdlib/builtin/: lv_mem_core_builtin.c lv_sprintf_builtin.c lv_string_builtin.c lv_tlsf.c
  group Middlewares/LVGL/Themes
    ../Middlewares/lvgl/src/themes/: lv_theme.c
    ../Middlewares/lvgl/src/themes/basic/: lv_theme_basic.c
    ../Middlewares/lvgl/src/themes/default/: lv_theme_default.c
    ../Middlewares/lvgl/src/themes/mono/: lv_theme_mono.c
  group Middlewares/LVGL/Tick
    ../Middlewares/lvgl/src/tick/: lv_tick.c
  group Middlewares/LVGL/Widgets
    ../Middlewares/lvgl/src/widgets/arc/: lv_arc.c
    ../Middlewares/lvgl/src/widgets/bar/: lv_bar.c
    ../Middlewares/lvgl/src/widgets/dropdown/: lv_dropdown.c
    ../Middlewares/lvgl/src/widgets/label/: lv_label.c
    ../Middlewares/lvgl/src/widgets/led/: lv_led.c
    ../Middlewares/lvgl/src/widgets/line/: lv_line.c
    ../Middlewares/lvgl/src/widgets/roller/: lv_roller.c
    ../Middlewares/lvgl/src/widgets/slider/: lv_slider.c
target usb-flashin (6190000::V6.19::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: usb +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/At/include;../Middlewares/Third_Party/mem;../FATFS/Target;../FATFS/App;../Middlewares/Third_Party/FatFs/src;../Middlewares/Third_Party/SD;../USB_DEVICE/App;../USB_DEVICE/Target;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;..\Middlewares\Third_Party\FFT\include;..\Middlewares\lvgl;..\Middlewares\lvgl\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
software components: CMSIS:CORE 5.6.0
