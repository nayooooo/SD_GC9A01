# Keil uVision project uss.uvprojx, settings and files
target uss-lvglv8.2.0 (6190000::V6.19::ARMCLANG)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: uss +hex
  c flags: Optim=7 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Applications/At/include;../Middlewares/Third_Party/mem/include;../Middlewares/Third_Party/At/include;../Middlewares/Third_Party/WS2812B/include;../Middlewares/Third_Party/LCD/include;../Middlewares/lvgl;../Middlewares/lvgl/src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Application/User/At
    ../Applications/At/: at_user.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/mem
    ../Middlewares/Third_Party/mem/: malloc.c
  group Middlewares/At
    ../Middlewares/Third_Party/At/: at.c at_mem.c at_stream_device.c
  group Middlewares/LCD
    ../Middlewares/Third_Party/LCD/: lcd.c lcd_init.c CST816S.c CTIIC.c
  group Middlewares/WS2812B
    ../Middlewares/Third_Party/WS2812B/: ws2812b.c
  group Middlewares/LVGL/App
    ../Middlewares/lvgl/app/: lvgl_app.c
  group Middlewares/LVGL/Port
    ../Middlewares/lvgl/: lv_port_disp.c lv_port_indev.c
  group Middlewares/LVGL/Core
    ../Middlewares/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Middlewares/LVGL/Draw
    ../Middlewares/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group Middlewares/LVGL/Extra
    ../Middlewares/lvgl/src/extra/: lv_extra.c
    ../Middlewares/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Middlewares/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Middlewares/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c lv_fs_posix.c lv_fs_stdio.c lv_fs_win32.c
    ../Middlewares/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
    ../Middlewares/lvgl/src/extra/libs/png/: lodepng.c lv_png.c
    ../Middlewares/lvgl/src/extra/libs/qrcode/: lv_qrcode.c qrcodegen.c
    ../Middlewares/lvgl/src/extra/libs/rlottie/: lv_rlottie.c
    ../Middlewares/lvgl/src/extra/libs/sjpg/: lv_sjpg.c tjpgd.c
    ../Middlewares/lvgl/src/extra/others/gridnav/: lv_gridnav.c
    ../Middlewares/lvgl/src/extra/others/monkey/: lv_monkey.c
    ../Middlewares/lvgl/src/extra/others/snapshot/: lv_snapshot.c
    ../Middlewares/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/lvgl/src/extra/themes/mono/: lv_theme_mono.c
    ../Middlewares/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middlewares/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middlewares/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middlewares/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/lvgl/src/extra/widgets/win/: lv_win.c
  group Middlewares/LVGL/Font
    ../Middlewares/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Middlewares/LVGL/Hal
    ../Middlewares/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Middlewares/LVGL/Misc
    ../Middlewares/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_templ.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Middlewares/LVGL/Widgets
    ../Middlewares/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
software components: CMSIS:CORE 5.6.0
